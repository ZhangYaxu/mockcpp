# IAR project mockcpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPPUTEST_STD_CPP_LIB_DISABLED; MOCKCPP_ALLOW_MULTI_INHERITANCE=1; MOCKCPP_MAX_INHERITANCE=2; MOCKCPP_MAX_PARAMETERS=12; MOCKCPP_MAX_VTBL_SIZE=20; MOCKCPP_NO_NAMESPACE=0; PACKAGE="mockcpp"; PACKAGE_BUGREPORT="dev.mockcpp@gmail.com"; PACKAGE_NAME="mockcpp"; PACKAGE_STRING="mockcpp"; PACKAGE_URL="http://code.google.com/p/mockcpp"; VERSION="2.6"
  ICCARM.CCIncludePath2: ..\..\cpputest\include; ..\include; ..\3rdparty
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: CppUTest.srec
  ILINK.IlinkOutputFile: CppUTest.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group src/mockcpp
    ../src/: AfterMatcher.cpp Any.cpp AnyBase.cpp AnyCast.cpp ApiHook.cpp ApiHookKey.cpp Asserter.cpp AssertionFailedError.cpp BeforeMatcher.cpp CallerMatcher.cpp ChainableMockMethodContainer.cpp ChainableMockMethodCore.cpp ChainableMockMethodIndexKey.cpp ChainableMockMethodNameKey.cpp ChainableMockObject.cpp ChainableMockObjectBase.cpp ChainingMockHelper.cpp ConstraintSet.cpp DecoratedConstraint.cpp DefaultMatcher.cpp DefaultStub.cpp DelegatedMethodGetter.cpp DieStub.cpp Exception.cpp ExpectsMatcher.cpp Formatter.cpp GlobalMockObject.cpp HookMockObject.cpp IdentityBuilder.cpp IgnoreResultHandler.cpp IgnoreResultHandlerFactory.cpp IgnoreReturnStub.cpp InterfaceInfo.cpp Invocation.cpp InvocationId.cpp InvocationMockBuilderGetter.cpp InvocationMocker.cpp InvocationMockerSet.cpp InvocationTimesMatcher.cpp InvokedAtLeast.cpp InvokedAtMost.cpp InvokedExactly.cpp InvokedOnce.cpp InvokedTimesMatcher.cpp IsAnythingHelper.cpp IsStringContains.cpp IsStringEndWith.cpp IsStringStartWith.cpp JmpCode.cpp JmpCodeArch.h JmpCodeX64.h JmpCodeX86.h JmpOnlyApiHook.cpp JmpOnlyApiHook.h MethodIndiceChecker.cpp MismatchResultHandler.cpp MismatchResultHandlerFactory.cpp MockObjectBase.cpp NormalResultHandler.cpp NormalResultHandlerFactory.cpp OutBoundPointer.cpp PendingMatcher.cpp ProcStub.cpp RefAny.cpp RepeatStub.cpp Result.cpp ReturnObjectList.cpp ReturnStub.cpp SimpleInvocationRecorder.cpp StringConstraint.cpp StubContainer.cpp StubsMatcher.cpp TestFailureMatcher.cpp ThenStub.cpp TypelessConstraintAdapter.cpp TypelessStubAdapter.cpp TypeString.cpp UnixCodeModifier.cpp VirtualTable.cpp VirtualTableUtils.cpp VoidResultHandler.cpp VoidResultHandlerFactory.cpp WillStub.cpp
    ../src/ports/failure/: cpputest_report_failure.cpp
